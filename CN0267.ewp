# IAR project CN0267.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM360 AnalogDevices ADuCM360
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FLASH_ACCESS
  ICCARM.CCIncludePath2: $EW_DIR$\arm\inc\AnalogDevices; src; src\include; src\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CN0267.hex
  ILINK.IlinkOutputFile: CN0267.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    src/: AD5421.c ADC_RTD.c FlashEraseWrite.c HART_AD5700.c main.c
  group common
    src/common/: AdcLib.c ClkLib.c DioLib.c IntLib.c SpiLib.c UrtLib.c WdtLib.c
  group Startup_Code
    src/common/IAR/: startup_ADuCM360.s
